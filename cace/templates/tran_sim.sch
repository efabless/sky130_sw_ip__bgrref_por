** sch_path: cace/templates/tran_sim.sch
**.subckt tran_sim por porb porb_h[1],porb_h[0]
*.opin por
*.opin porb
*.opin porb_h[1],porb_h[0]
Vdvss dvss GND DC CACE{Vdvss}
Vavdd avdd GND PULSE 0 CACE{Vavdd} 1.5m CACE{travdd} CACE{travdd} 0.5 1
Vavss avss GND DC CACE{Vavss}
Vdvdd dvdd GND PULSE 0 CACE{Vdvdd} 10n CACE{trdvdd} CACE{trdvdd} 0.5 1
Vvbg vbg GND PULSE 0 CACE{Vvbg} 1.5m '0.33*CACE{travdd}' '0.33*CACE{travdd}' 0.5 1
XDUT vbg por avss avdd dvdd porb dvss porb_h[1] porb_h[0] sky130_sw_ip__bgrref_por
C1 por GND CACE{CLb} m=1
C2 porb GND CACE{CLb} m=1
C3 porb_h[0] GND CACE{CLw} m=1
C4 porb_h[1] GND CACE{CLw} m=1
**** begin user architecture code


* CACE gensim simulation file CACE{filename}
* Generated by CACE gensim, Efabless Corporation (c) 2024
* Find the powerup simulation of POR

.include CACE{DUT_path}
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hvl/spice/sky130_fd_sc_hvl.spice
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_ls/spice/sky130_fd_sc_ls.spice

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}
*.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




*.options savecurrents
.control
*save all

tran CACE{Tstep} CACE{Tsim}

write CACE{simpath}/CACE{filename}_CACE{N}.raw
echo CACE{simpath}/CACE{filename}_CACE{N}.raw >> CACE{simpath}/../CACE{filename}_base_file.txt

meas tran Iavdd AVG i(Vavdd) from=0 to=CACE{Tsim}
meas tran Idvdd AVG i(Vdvdd) from=0 to=CACE{Tsim}
let Iavg=abs(Iavdd)+abs(Idvdd)

let Tstart = CACE{Tsim}-1m
meas tran Iavdd_ss AVG i(Vavdd) from=$&Tstart to=CACE{Tsim}
meas tran Idvdd_ss AVG i(Vdvdd) from=$&Tstart to=CACE{Tsim}
let Iavg_ss=abs(Iavdd_ss)+abs(Idvdd_ss)


let dvdd_half = 0.5*CACE{Vdvdd}
let dvdd_approx = 0.99999*CACE{Vdvdd}
let avdd_approx = 0.99999*CACE{Vavdd}
let vss_approx = 0.00001*CACE{Vdvss}

meas tran V_thp FIND v(avdd) WHEN v(xdut.rst)=dvdd_half RISE=LAST

meas tran porPulse TRIG v(por) VAL=dvdd_half RISE=LAST TARG v(por) VAL=dvdd_half FALL=LAST

meas tran tpor_low WHEN v(por)=vss_approx FALL=LAST
meas tran Vlow_por MAX v(por) from=tpor_low to=CACE{Tsim}

meas tran tporb_high WHEN v(porb)=dvdd_approx RISE=LAST
meas tran Vhigh_porb MIN v(porb) from=tporb_high to=CACE{Tsim}
let Vhigh_porb_delta = Vhigh_porb - CACE{Vdvdd}

meas tran tporbh_high WHEN v(porb_h[0])=avdd_approx RISE=LAST
meas tran Vhigh_porbh MIN v(porb_h[0]) from=tporbh_high to=CACE{Tsim}
let Vhigh_porbh_delta = Vhigh_porbh - CACE{Vavdd}

meas tran tpor_high_up WHEN v(por)=dvdd_approx RISE=LAST
meas tran tpor_high_dn WHEN v(por)=dvdd_approx FALL=LAST
meas tran Vhigh_por MIN v(por) from=tpor_high_up to=tpor_high_dn
let Vhigh_por_delta = Vhigh_por - CACE{Vdvdd}

meas tran tporb_low_up WHEN v(porb)=vss_approx RISE=LAST
meas tran Vlow_porb MAX v(porb) from=tpor_high_up to=tporb_low_up

meas tran tporbh_low_up WHEN v(porb_h[0])=vss_approx RISE=LAST
meas tran Vlow_porbh MAX v(porb_h[0]) from=tpor_high_up to=tporbh_low_up

echo $&Iavg $&Iavg_ss $&V_thp $&porPulse $&Vlow_por $&Vlow_porb $&Vlow_porbh $&Vhigh_por_delta $&Vhigh_porb_delta $&Vhigh_porbh_delta > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
