** sch_path: cace/templates/por_hys_plot.sch
**.subckt por_hys_plot por porb porb_h[1],porb_h[0]
*.opin por
*.opin porb
*.opin porb_h[1],porb_h[0]
Vdvss dvss GND DC CACE{Vdvss}
Vavdd avdd GND PULSE 0 CACE{Vavdd} 10n CACE{travdd} 1m 1m 4m
Vavss avss GND DC CACE{Vavss}
XDUT1 vbg por avss avdd dvdd porb dvss porb_h[1] porb_h[0] sky130_sw_ip__bgrref_por
C1 por GND CACE{CLb} m=1
C2 porb GND CACE{CLb} m=1
C3 porb_h[0] GND CACE{CLw} m=1
C4 porb_h[1] GND CACE{CLw} m=1
Vdvdd2 dvdd GND DC CACE{Vdvdd}
Vvbg2 vbg GND DC CACE{Vvbg}
R1 porb_h1 porb_h[1] 0 m=1
R2 porb_h0 porb_h[0] 0 m=1
**** begin user architecture code


* CACE gensim simulation file CACE{filename}
* Generated by CACE gensim, Efabless Corporation (c) 2024
* Find the powerup simulation of POR

.include CACE{DUT_path}
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hvl/spice/sky130_fd_sc_hvl.spice
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_ls/spice/sky130_fd_sc_ls.spice

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}
*.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




*.options savecurrents
.control
*save all

tran CACE{Tstep} CACE{Tsim}
set wr_singlescale
wrdata CACE{simpath}/CACE{filename}_CACE{N}.data V(avdd) V(dvdd) V(vbg) V(por) V(porb) V(porb_h0)
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
