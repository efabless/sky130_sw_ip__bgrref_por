** sch_path: cace/templates/por_supply_glitch.sch
**.subckt por_supply_glitch por porb porb_h[1],porb_h[0]
*.opin por
*.opin porb
*.opin porb_h[1],porb_h[0]
Vdvss dvss GND DC CACE{Vdvss}
Vavdd net1 avdd PULSE 0 {Vglitch} 1m 0.5m 0.5m {Vglitch_dur} 1
Vavss avss GND DC CACE{Vavss}
Vdvdd dvdd GND DC CACE{Vdvdd}
Vvbg vbg GND DC CACE{Vvbg}
XDUT1 vbg por avss avdd dvdd porb dvss porb_h[1] porb_h[0] sky130_sw_ip__bgrref_por
C1 por GND CACE{CLb} m=1
C2 porb GND CACE{CLb} m=1
C3 porb_h[0] GND CACE{CLw} m=1
C4 porb_h[1] GND CACE{CLw} m=1
Vavdd1 net1 GND DC CACE{Vavdd}
**** begin user architecture code


* CACE gensim simulation file CACE{filename}
* Generated by CACE gensim, Efabless Corporation (c) 2024
* Find the powerup simulation of POR

.include CACE{DUT_path}
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hvl/spice/sky130_fd_sc_hvl.spice
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_ls/spice/sky130_fd_sc_ls.spice

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}
*.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1



.param Vglitch = CACE{Vavdd}
.param Vglitch_dur = CACE{Tsim}

.tran CACE{Tstep} CACE{Tsim}

.control
let dvdd_half = 0.5*CACE{Vdvdd}
* glitch duration sweep loop
*let stop_dur = CACE{Tsim}
let stop_dur = 200u
let delta_dur = 5u
let dur_act = 10u
while dur_act le stop_dur
 alterparam Vglitch_dur = $&dur_act
 reset
 run
 meas tran por_val FIND v(por) AT = CACE{Tsim}
 if por_val > dvdd_half
   echo $&dur_act  > CACE{simpath}/CACE{filename}_CACE{N}.data
   alterparam Vglitch_dur = $&dur_act
   let dur_act = dur_act + stop_dur
 else
   let dur_act = dur_act + delta_dur
 end
end

* glitch amplitude sweep loop
let stop_amp = CACE{Vavdd}
let delta_amp = 100m
let amp_act = 100m
while amp_act le stop_amp
 alterparam Vglitch = $&amp_act
 reset
 run
 meas tran por_val FIND v(por) AT = CACE{Tsim}
 if por_val > dvdd_half
   echo $&amp_act  >> CACE{simpath}/CACE{filename}_CACE{N}.data
   let amp_act = amp_act + stop_amp
 else
   let amp_act = amp_act + delta_amp
 end
end
quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
